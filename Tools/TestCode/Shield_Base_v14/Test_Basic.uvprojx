# Keil uVision project Test_Basic.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Test_Basic
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CLOCK_SETUP=1
  c include: ./Include;./Source;./Source/LCD;./Source/Profiler
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Source/: debug.c delay.c LEDs.c main.c threads.c timers.c ADC.c I2C.c MMA8451.c sound.c OL_HBLED.c DMA.c
  group LCD
    ./Source/LCD/: LCD_graphics.c LCD_text.c lucida_8x13.c lucida_12x19.c lucida_20x31.c ST7789.c T6963.c touchscreen.c colors.c
  group Profiler
    ./Source/Profiler/: profile.c region.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 2.5.0
