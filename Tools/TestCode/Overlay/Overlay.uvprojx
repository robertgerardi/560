# Keil uVision project Overlay.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Overlay
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: Fonts;Profiling
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT5: ROM 0x8000 size 0x18000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c
  group Fonts
    ./Fonts/: font.h lucida_8x13.c lucida_12x19.c lucida_20x31.c
  group Profiler
    ./Profiler/: region.h regiontable.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.5.0
